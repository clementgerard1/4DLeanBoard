Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2020-09-22T12:30:49
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.0.0.383 - Exporter 21.0.0.383 - Alternate UI 21.0.0.383
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Sep 22 12:30:49 2020 * Host: DESKTOP-DG8BND5 * Database: C:\Users\X\AppData\Local\Temp\0e8731ab-be52-4f65-b80d-0ece04a154c0\6927dc03-5de0-41f3-8c38-d7cbde730a6d\ifc * Database version: 5507 * Database creation date: Tue Sep 22 12:29:56 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Sep 22 12:29:57 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Sep 22 12:29:57 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Surface:579661
RefLatitude: 48, 41, 46, 352233; RefLongitude: 6, 11, 34, 519615; RefElevation: 0 mm
Pset_ProductRequirements - Category: Topography; sets with these values: 2
Dimensions - Projected Area: 922.631 m2; Surface Area: 922.639 m2
Identity Data - Comments: ThisIsExisiting
Materials and Finishes - Material: Concrete, Walkway
Other - Category: Topography; Cut: 0 m3; Fill: 0 m3; Net cut/fill: 0 m3
Phasing - Phase Created: Existing

# IfcBuilding
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status
Pset_BuildingCommon - NumberOfStoreys: 4
Pset_ProductRequirements - Category: Project Information

# IfcBuildingStorey: Level:Circle Head - Project Datum (4)
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: Circle Head - Project Datum
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: Anno_Level_Head_Circle: Standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: no
Constraints(Type) - Elevation Base: Project Base Point
Pset_ProductRequirements - Category: Levels
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes
Other - Category: Levels; Family: Level: Circle Head - Project Datum; Family and Type: Level: Circle Head - Project Datum; Type: Level: Circle Head - Project Datum; Type Id: Level: Circle Head - Project Datum
Name | LongName = Pset_AirSideSystemInformation, Name = Pset_ProductRequirements, Name = Identity Data, Name | Elevation (mm) = Constraints, Elevation (mm) | Structural
R-1 | R-1 | -3500 | yes
RDC | RDC | 0 | no
R+1 | R+1 | 3660 | no
R+2 | R+2 | 7320 | no

# IfcColumn: M_Precast-Square Column:430x430 Main floor (3)
Type - PredefinedType: COLUMN; Material: Concrete, Precast Smooth, Light Grey
Type - Dimensions - b: 430 mm; Chamfer: 0 mm
Type - Identity Data - OmniClass Number: 23.25.30.11.14.11; OmniClass Title: Columns; Type Name: 430x430 Main floor
Type - Other - Category: Structural Columns; Family Name: M_Precast-Square Column; TransChamfer: 2 mm
Type - Structural - Section Shape: 0
Type - Pset_ColumnCommon - IsExternal: no; Reference: 430x430 Main floor; LoadBearing: yes
Type - Pset_ProductRequirements - Category: Structural Columns
Type - Pset_QuantityTakeOff - Reference: 430x430 Main floor
Type - Pset_ReinforcementBarPitchOfColumn - Reference: 430x430 Main floor
Pset_QuantityTakeOff - sets with these values: 2
Constraints - Base Offset: 0 mm; Moves With Grids: yes; Room Bounding: yes; Top Offset: 0 mm; Column Location Mark: 1-20(37205.0); Column Style: Vertical
Identity Data - Comments: ThisIsExisting
Materials and Finishes - Structural Material: Concrete, Precast Smooth, Light Grey
Other - Family: M_Precast-Square Column: 430x430 Main floor; Family and Type: M_Precast-Square Column: 430x430 Main floor; Rebar Grids W: 0.98 kN; Single Rebar W: 0.49 kN; Tie Rod W: 0.294 kN; Type: M_Precast-Square Column: 430x430 Main floor; Type Id: M_Precast-Square Column: 430x430 Main floor
Phasing - Phase Created: Existing
Structural - Enable Analytical Model: yes; Rebar Cover - Bottom Face: Rebar Cover Settings: Rebar Cover 1; Rebar Cover - Other Faces: Rebar Cover Settings: Rebar Cover 1; Rebar Cover - Top Face: Rebar Cover Settings: Rebar Cover 1; Rebar Grids Weight: 100; Single Rebar Weight: 50; Tie Rod Weight: 30
Name (M_Precast-Square Column:430x430 Main floor:...) | In | Base Level = Level | Top Level | Length (mm) | Volume (m3)
545167 | R+1 | Level: R+1 | Level: R+2 | 3660 | 0.676734
548625 | R+2 | Level: R+2 | Level: TOP | 3910 | 0.722959
556782 | RDC | Level: RDC | Level: R+1 | 3660 | 0.676734

# IfcColumn: M_Rectangular Column:Cils (54)
In: R-1
Type - PredefinedType: COLUMN; Material: Concrete, Precast Smooth, Light Grey
Type - Dimensions - Depth: 475 mm; Offset Base: 0 mm; Offset Top: 0 mm; Width: 475 mm
Type - Graphics - Coarse Scale Fill Color: 0
Type - Identity Data - OmniClass Number: 23.25.30.11.14.11; OmniClass Title: Columns; Type Name: Cils
Type - Materials and Finishes - Material: Concrete, Precast Smooth, Light Grey
Type - Other - Category: Columns; Family Name: M_Rectangular Column
Type - Pset_ColumnCommon - Reference: Cils; IsExternal: no
Type - Pset_ProductRequirements - Category: Columns
Type - Pset_QuantityTakeOff - Reference: Cils
Type - Pset_ReinforcementBarPitchOfColumn - Reference: Cils
Pset_QuantityTakeOff - sets with these values: 2
Constraints - Base Level: Level: R-1; Base Offset: 0 mm; Level: Level: R-1; Moves With Grids: yes; Room Bounding: yes; Top Level: Level: TOP; Top Offset: 0 mm
Dimensions - Volume: 10.8243 m3
Identity Data - Comments: ThisIsExisting
Other - Family: M_Rectangular Column: Cils; Family and Type: M_Rectangular Column: Cils; Type: M_Rectangular Column: Cils; Type Id: M_Rectangular Column: Cils
Phasing - Phase Created: Existing
Name (M_Rectangular Column:Cils:...)
397267
398352
398382
398386
398390
398394
398398
398402
398406
398410
398414
398418
398422
398426
398430
398434
398438
398442
398446
398450
398454
398458
398462
398466
398470
398497
398501
398505
398509
398513
398522
398526
398530
398534
398538
398555
400127
400129
400131
400133
400135
400137
400139
400141
400143
400145
400147
400149
400151
400153
400155
400172
400184
400196
